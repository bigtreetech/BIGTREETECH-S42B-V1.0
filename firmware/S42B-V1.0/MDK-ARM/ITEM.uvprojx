# Keil uVision project ITEM.uvprojx, settings and files
target ITEM (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F030C8 STMicroelectronics
  pack: Keil.STM32F0xx_DFP.2.0.0
  cpu: IRAM(0x20000000-0x20001FFF) IROM(0x8000000-0x800FFFF) CLOCK(8000000) CPUTYPE("Cortex-M0")
  output: ITEM +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_FULL_LL_DRIVER,STM32F030x8
  c include: ../Inc;../Drivers/STM32F0xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F0xx/Include;../Drivers/CMSIS/Include;..\Hardware
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group Application/MDK-ARM
    ./: startup_stm32f030x8.s
  group Application/User
    ../Src/: stm32f0xx_it.c main.c
  group Drivers/CMSIS
    ..//Src/: system_stm32f0xx.c
  group Drivers/STM32F0xx_HAL_Driver
    ../Drivers/STM32F0xx_HAL_Driver/Src/: stm32f0xx_ll_tim.c stm32f0xx_ll_pwr.c stm32f0xx_ll_spi.c stm32f0xx_ll_dma.c stm32f0xx_ll_rcc.c stm32f0xx_ll_usart.c stm32f0xx_ll_exti.c stm32f0xx_ll_gpio.c stm32f0xx_ll_utils.c
  group Hardware
    ../Hardware/: oled.c display.c usart.c
software components: CMSIS:CORE 4.3.0
